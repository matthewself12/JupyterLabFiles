options:
  parameters:
    generate_options: qt_gui
    id: TemperatureDecoder
    output_language: python
    title: TemperatureDecoder
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    label: Alpha Value
    start: '1e-6'
    step: '100e-7'
    stop: '1e-1'
    value: '1e-4'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '433946924'
  states: {}
- name: powerSq
  id: variable_qtgui_range
  parameters:
    label: Power Squelch (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-44'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: alpha
    gate: 'True'
    ramp: '0'
    threshold: powerSq
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/squelchedData
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/rawData2
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '100000'
    type: complex
  states: {state: disabled}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: '20000000'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '15000000'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.15'
    init: '0'
    low: '0.05'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 3e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '200000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '15000000'
    x_start: '0'
    x_step: '1000'
    ymax: '2'
    ymin: '-1'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_head_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_1, '0', blocks_file_sink_0_0, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_threshold_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_number_sink_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', blocks_head_1, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
